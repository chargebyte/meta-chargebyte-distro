DEPENDS:class-native += "libunwind-native"
