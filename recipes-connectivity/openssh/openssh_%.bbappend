# don't pull rng-tools into image
PACKAGECONFIG:remove = "rng-tools"
