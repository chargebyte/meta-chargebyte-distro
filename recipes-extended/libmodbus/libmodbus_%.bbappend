SRC_URI = "git://github.com/chargebyte/libmodbus.git;protocol=https;branch=i2se-master"

SRCREV = "6aeadb14324002d28b3df9d01242cd416058e614"

PV = "3.1.7+git${SRCPV}"
S = "${WORKDIR}/git"

DEFAULT_PREFERENCE = "1"
