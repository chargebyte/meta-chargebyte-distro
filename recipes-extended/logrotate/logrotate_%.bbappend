FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://enable-service.patch"
