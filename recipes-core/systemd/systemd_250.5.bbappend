FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += " \
    file://0001-network-do-not-enable-IPv4-ACD-for-IPv4-link-local-a.patch \
"
