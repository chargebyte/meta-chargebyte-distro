# do not install systemd.service units for serial console
# (one for /dev/console is automatically created)
#SERIAL_CONSOLES = ""
