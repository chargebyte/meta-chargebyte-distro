FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += " \
    file://0001-src-bundle-allow-exFAT-as-local-file-system.patch \
"
