# disable python
PACKAGECONFIG ?= "locale"